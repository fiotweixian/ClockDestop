# Keil uVision project ClockDestop.uvprojx, settings and files
target ClockDestop (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ClockDestop +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ZLG_GUI;..\DSPLIB;..\APP\APP;..\APP\MP3;..\APP\Snake;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\RTC;..\HARDWARE\SHT20;..\HARDWARE\SPI;..\HARDWARE\TIME;..\SYSTEM\delay;..\SYSTEM\usart;..\APP\BTrix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group SYETEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group DSP_Lib
    ../DSPLIB/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
  group Drivers
    ../Src/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group Application
    ./: startup_stm32f103xb.s
  group ZLG_GUI
    ../ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SHT20/: sht20.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIME/: tim.c
  group APP
    ../APP/APP/: display.c
    ../APP/MP3/: mp3.c
    ../APP/Snake/: snake.c
software components: CMSIS:CORE 4.1.0
